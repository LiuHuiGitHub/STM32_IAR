<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\Driver\drive_e2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\drive_e2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\drive_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\drive_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\drive_ir.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\drive_ir.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\drive_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Driver\drive_usart.h</name>
    </file>
  </group>
  <group>
    <name>Hwa</name>
    <file>
      <name>$PROJ_DIR$\Hwa\hwa_key.c</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\startup_stm32f10x_hd.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\startup_stm32f10x_md.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\system_stm32f10x.c</name>
      </file>
    </group>
    <group>
      <name>STD_LIB</name>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\STM32F10x_StdPeriph_Driver\src\stm32f10x_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>System</name>
    <file>
      <name>$PROJ_DIR$\System\sys.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_can.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_count.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_count.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_cpu .h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_cpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_dac.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_exti.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_key.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_pwm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_rtc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_tim.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_usart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_watchDog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\System\sys_watchDog.h</name>
    </file>
  </group>
  <group>
    <name>USB</name>
    <group>
      <name>LIB</name>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_def.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_init.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_int.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_lib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_mem.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_regs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_regs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_sil.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_sil.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\lib\usb_type.h</name>
      </file>
    </group>
    <group>
      <name>SRC</name>
      <file>
        <name>$PROJ_DIR$\USB\src\hw_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\hw_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\platform_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_desc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_desc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_endp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_istr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_istr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_prop.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_prop.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\USB\src\usb_pwr.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\system.c</name>
    </file>
  </group>
  <group>
    <name>UserLib</name>
    <file>
      <name>$PROJ_DIR$\UserLib\Queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\UserLib\Queue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\UserLib\uLib_PID.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\UserLib\uLib_PID.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\UserLib\uLib_queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\UserLib\uLib_queue.h</name>
    </file>
  </group>
</project>


