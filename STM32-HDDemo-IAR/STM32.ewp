# IAR project STM32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; User; System; RTT; Hwa; Driver; Driver\LCD_Driver; Driver\Touch; USB\lib; USB\src; UserLib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32-Demo.bin
  ILINK.IlinkOutputFile: STM32-Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Driver
    Driver/: drive_e2.c drive_e2.h drive_flash.c drive_flash.h drive_ir.c drive_ir.h drive_usart.c drive_usart.h
  group Hwa
    Hwa/: hwa_key.c
  group Library/CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Library/STD_LIB
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    System/: sys.h sys_adc.c sys_adc.h sys_can.c sys_can.h sys_clock.c sys_conf.h sys_core.c sys_count.c sys_count.h sys_cpu .h sys_cpu.c sys_dac.c sys_dac.h sys_exti.c sys_exti.h sys_key.c sys_key.h sys_pwm.c sys_pwm.h sys_rtc.c sys_rtc.h sys_tim.c sys_tim.h sys_usart.c sys_usart.h sys_watchDog.c sys_watchDog.h
  group USB/LIB
    USB/lib/: usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
  group USB/SRC
    USB/src/: hw_config.c hw_config.h platform_config.h usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_it.c usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group User
    User/: main.c stm32f10x_it.c system.c
  group UserLib
    UserLib/: Queue.c Queue.h uLib_PID.c uLib_PID.h uLib_queue.c uLib_queue.h
